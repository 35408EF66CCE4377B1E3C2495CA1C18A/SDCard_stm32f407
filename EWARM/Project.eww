<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32CubeMX_UCOSIII_f407_Template.ewp</path>
  </project>
  <batchBuild />
</workspace>
