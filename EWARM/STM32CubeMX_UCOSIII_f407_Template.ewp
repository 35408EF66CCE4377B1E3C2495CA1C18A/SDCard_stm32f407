# IAR project STM32CubeMX_UCOSIII_f407_Template.ewp, settings and files
configuration STM32CubeMX_UCOSIII_f407_Template Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\UCOSIII\uC-CPU; ..\UCOSIII\uC-LIB; ..\UCOSIII\uCOS-III; ..\UCOSIII\UCOS_BSP; ..\UCOSIII\uCOS_CONFIG; ..\UCOSIII\uCOS-III\Source; ..\UCOSIII\uC-CPU\ARM-Cortex-M4\IAR; ..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\IAR; ..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\Hardwares\inc; ..\Hardwares\inc\w5500; ..\Hardwares\src\w5500; ..\Hardwares\src\w5500\Application; ..\Hardwares\src\w5500\Application\loopback; ..\Hardwares\src\w5500\Ethernet\W5500; ..\Hardwares\src\w5500\Ethernet; ..\Middlewares\Third_Party\FatFs\src; ..\Middlewares\Third_Party\FatFs\src\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32CubeMX_UCOSIII_f407_Template.srec
  ILINK.IlinkOutputFile: STM32CubeMX_UCOSIII_f407_Template Configuration.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s startup_stm32f407xx.s startup_stm32f407xx.s startup_stm32f407xx.s startup_stm32f407xx.s startup_stm32f407xx.s startup_stm32f407xx.s startup_stm32f407xx.s startup_stm32f407xx.s startup_stm32f407xx.s
  group Application/User
    ../Src/: adc.c bsp_driver_sd.c dma.c fatfs.c gpio.c main.c retarget_iar.c rtc.c sdio.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c fatfs.c spi.c main.c stm32f4xx_it.c gpio.c bsp_driver_sd.c stm32f4xx_hal_msp.c rtc.c dma.c usart.c adc.c sdio.c fatfs.c spi.c main.c stm32f4xx_it.c gpio.c bsp_driver_sd.c stm32f4xx_hal_msp.c rtc.c dma.c usart.c adc.c sdio.c fatfs.c spi.c main.c stm32f4xx_it.c gpio.c bsp_driver_sd.c stm32f4xx_hal_msp.c rtc.c dma.c usart.c adc.c sdio.c fatfs.c spi.c main.c stm32f4xx_it.c gpio.c bsp_driver_sd.c stm32f4xx_hal_msp.c rtc.c dma.c usart.c adc.c sdio.c fatfs.c spi.c main.c stm32f4xx_it.c gpio.c bsp_driver_sd.c stm32f4xx_hal_msp.c rtc.c dma.c usart.c adc.c sdio.c fatfs.c spi.c main.c stm32f4xx_it.c gpio.c bsp_driver_sd.c stm32f4xx_hal_msp.c rtc.c dma.c usart.c adc.c sdio.c fatfs.c spi.c main.c stm32f4xx_it.c gpio.c bsp_driver_sd.c stm32f4xx_hal_msp.c rtc.c dma.c usart.c adc.c sdio.c fatfs.c spi.c main.c stm32f4xx_it.c gpio.c bsp_driver_sd.c stm32f4xx_hal_msp.c rtc.c dma.c usart.c adc.c sdio.c fatfs.c spi.c main.c stm32f4xx_it.c gpio.c bsp_driver_sd.c stm32f4xx_hal_msp.c rtc.c dma.c usart.c adc.c sdio.c
  group Application/W5500
    ../Hardwares/src/w5500/Application/loopback/: loopback.c
    ../Hardwares/src/w5500/Ethernet/: socket.c
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c
  group Drivers/W5500
    ../Hardwares/src/w5500/Ethernet/W5500/: w5500.c
    ../Hardwares/src/w5500/Ethernet/: wizchip_conf.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c syscall.c syscall.c syscall.c syscall.c syscall.c syscall.c syscall.c syscall.c syscall.c
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group UCOSIII/uC-BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII/uC-CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOSIII/uC-CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII/uC-CPU
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm cpu_c.c
    ../UCOSIII/uC-CPU/: cpu_core.c
  group UCOSIII/uC-LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group UCOSIII/uC-PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
