# Keil uVision project STM32CubeMX_UCOSIII_f407_Template.uvprojx, settings and files
target STM32CubeMX_UCOSIII_f407_Template Configuration (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32CubeMX_UCOSIII_f407_Template Configuration +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__DEBUG_INFO__
  c include: ..\Inc;                    ..\Drivers\STM32F4xx_HAL_Driver\Inc;                    ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;                    ..\Drivers\CMSIS\Include;                    ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;                    ..\UCOSIII\uC-CPU;                    ..\UCOSIII\uC-LIB;                    ..\UCOSIII\uCOS-III;                    ..\UCOSIII\UCOS_BSP;                    ..\UCOSIII\uCOS_CONFIG;                    ..\UCOSIII\uCOS-III\Source;                    ..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;                    ..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;                    ..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;                    ..\Hardwares\inc;                    ..\Hardwares\inc\w5500;                    ..\Hardwares\src\w5500\Application;                    ..\Hardwares\src\w5500\Ethernet;                    ..\Hardwares\src\w5500\Ethernet\W5500;                    ..\Hardwares\src\w5500\Internet\DHCP;                    ..\Hardwares\src\w5500\Application\loopback;  ..\Middlewares\Third_Party\FatFs\src\drivers;  ..\Middlewares\Third_Party\FatFs\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc_ex.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c
  group Drivers/W5500
    ../Hardwares/src/w5500/Ethernet/W5500/: w5500.c
    ../Hardwares/src/w5500/Ethernet/: wizchip_conf.c
  group Application/W5500/Ethernet
    ../Hardwares/src/w5500/Ethernet/: socket.c
  group Application/W5500/Internet
    ../Hardwares/src/w5500/Internet/DHCP/: dhcp.c
  group Application/W5500/Application
    ../Hardwares/src/w5500/Application/loopback/: loopback.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Application/User
    ../Src/: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c adc.c dma.c gpio.c usart.c spi.c sdio.c retarget.c rtc.c fatfs.c bsp_driver_sd.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
